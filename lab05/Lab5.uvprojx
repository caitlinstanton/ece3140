# Keil uVision project Lab5.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MK64FN1M0VLL12 NXP
  pack: NXP.MK64F12_DFP.10.0.0
  cpu: IRAM(0x1fff0000,0x010000) IRAM2(0x20000000,0x030000) IROM(0x00000000,0x100000) XRAM(0x14000000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x14000000 size 0x1000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group Source Group 1
    ../../../../../../../../../../Downloads/: lab5_t0.c realtime.h 3140.s 3140_concur.c 3140_concur.h utils.c utils.h
    ./: process.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
