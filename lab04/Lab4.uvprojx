# Keil uVision project Lab4.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MK64FN1M0VLL12 NXP
  pack: NXP.MK64F12_DFP.10.0.0
  cpu: IRAM(0x1fff0000,0x010000) IRAM2(0x20000000,0x030000) IROM(0x00000000,0x100000) XRAM(0x14000000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab4
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x14000000 size 0x1000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: .\RTE\Device\MK64FN1M0VLL12\MK64FN1M0xxx12_flash.scf
  group Source Group 1
    ./: 3140_concur.c lab4_l0.c lab4_l1.c lab4_x0.c lab4_x1.c utils.c 3140.s 3140_concur.h cond.h lock.h shared_structs.h utils.h process.c lock.c test_l1.c test_l2.c cond.c test_c1.c test_c2.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0
